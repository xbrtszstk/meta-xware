# Copyright (c) 2024 Bartosz Szostak
# This software is released under the MIT License.
# See the LICENSE file for more details.

LICENSE = "MIT"

IMAGE_FEATURES = "hwcodecs"
IMAGE_INSTALL = "packagegroup-core-boot"

inherit core-image
